/* profile_mono.c - 128 x 64 SSD1306: four lines of NEODG16G (16 px, 1 bpp jamo set) drawn with MONO_PAGE straight into
 * the display's page layout (8 pages of 128 bytes), shown once. The face is a const array opened in place. */
#include <stdint.h>
#include <string.h>
#include "display.h"
#include "profile.h"
#include "svf.h"

extern const uint8_t svf_face_data[]; /* generated by c/bench/mkface.py at build time */
extern const uint32_t svf_face_data_len;

const char svf_port_profile_mono[] = "mono";
const char *const svf_port_text[] = {"Pico SVF 예제", "다람쥐 헌 쳇바퀴", "에 타고파! 1bpp", "안녕하세요"};
const int svf_port_text_n = 4;

static uint8_t frame[OLED_W * OLED_H / 8];

void profile_run(void)
{
	static svf_face face;
	svf_face *faces[1] = {&face};
	svf_chain chain;
	svf_target t;
	uint8_t scratch[32]; /* one 16 x 16 1 bpp cell: svf_chain_scratch_bytes of this chain */
	volatile const char *marker = svf_port_profile_mono;
	char keep = *marker; /* one volatile read: keeps the marker through -fdata-sections --gc-sections (nm check) */
	int i;

	(void)keep;
	memset(&chain, 0, sizeof chain);
	chain.faces = faces;
	chain.count = 1;
	if (svf_open_mapped(&face, svf_face_data, svf_face_data_len) != SVF_OK ||
	    svf_chain_scratch_bytes(&chain) > sizeof scratch ||
	    svf_target_init(&t, SVF_T_MONO_PAGE, frame, sizeof frame, OLED_W, OLED_H, OLED_W) != SVF_OK) {
		svf_port_idle();
		return;
	}
	memset(frame, 0, sizeof frame);
	/* Four 16 px lines; a line's baseline is the face's ascent below its top row. */
	for (i = 0; i < svf_port_text_n; ++i)
		if (svf_draw_utf8(&chain, svf_port_text[i], strlen(svf_port_text[i]), 0, (int16_t)(16 * i + svf_ascent(&face)),
		                  &t, scratch, sizeof scratch) != SVF_OK) {
			svf_port_idle();
			return;
		}
	display_show(frame, 0, OLED_H);
}
